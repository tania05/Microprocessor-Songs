# IAR project mpgl1-efmw-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3U2C Atmel ATSAM3U2C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; cmsis; bsp; drivers; application
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; cmsis; bsp
  OBJCOPY.OOCOutputFile: mpgl1-efmw-01.hex
  ILINK.IlinkOutputFile: mpgl1.out
  ILINK.IlinkIcfFile: bsp\sam3u2-flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Includes
    bsp/: AT91SAM3U4.h configuration.h exceptions.h interrupts.h mpgl1-ehdw-02.h sam3u2-flash.icf sam3u_uart.h
  group _BSP/Source
    bsp/: board_cstartup_iar.c exceptions.c interrupts.c mpgl1-ehdw-02.c sam3u_uart.c
  group _CMSIS
    cmsis/: core_cm3.c core_cm3.h
  group _Drivers/Include
    drivers/: buttons.h leds.h messaging.h utilities.h
  group _Drivers/Source
    drivers/: buttons.c leds.c messaging.c utilities.c
  group Application/Include
    application/: debug.h main.h mpgl1_audio_test.h mpgl1_song.h music.h typedefs.h
  group Application/Source
    application/: debug.c main.c mpgl1_audio_test.c mpgl1_song.c
